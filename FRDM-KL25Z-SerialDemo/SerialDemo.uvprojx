# Keil uVision project SerialDemo.uvprojx, settings and files
target Serial Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SerialDemo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CLOCK_SETUP=1
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./src/: main.c timers.c queue.c rgb.c uart0.c
  group inc
    ./inc/: timers.h queue.h rgb.h uart0.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0

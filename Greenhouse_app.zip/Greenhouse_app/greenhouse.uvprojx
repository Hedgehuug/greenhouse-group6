# Keil uVision project greenhouse.uvprojx, settings and files
target greenhouse (6160000::V6.16::ARMCLANG)
  device: MKL25Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: greenhouse
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source
    ./: main.c flags.c controlHeader.h
  group Headers
    ./: flags.h
  group SoilMoisture
    ./SoilM/: sensor.c sensor.h
  group Temp
    ./Temp/: DHT11.c DHT11.h
  group Lights
    ./Lights/: lights.c lights.h
  group tpm1
    ./tpm1/: TPM0.c TPM0.h
  group uart0
    ./uart0/: uart.c uart.h
  group queue
    ./queue/: queue.c queue.h
  group uart1
    ./uart1/: uart1.c uart1.h
  group LCD
    ./LCD/: LCD.c LCD.h
  group i2c
    ./i2c/: i2c.h i2c.c
  group LCD_Driver
    ./Driver/: driver.c driver.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0

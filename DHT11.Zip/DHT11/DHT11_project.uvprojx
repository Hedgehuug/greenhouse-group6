# Keil uVision project DHT11_project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DHT11_project
  c flags: Optim=4 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c include: .\TPM0;.\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./src/: main.c
  group TPM0
    ./src/: TPM0.c TPM0.h
  group DHT11
    ./src/: DHT11.h DHT11.c
  group Uart0
    ./src/: uart.h uart.c
  group Queue
    ./src/: queue.h queue.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0

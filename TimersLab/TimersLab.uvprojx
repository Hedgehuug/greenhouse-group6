# Keil uVision project TimersLab.uvprojx, settings and files
target Timers Lab (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TimersLab
  c flags: Optim=4 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c include: .\rgb;.\pit;.\queue;.\tpm1;.\uart0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group pit
    ./pit/: pit.c pit.h
  group queue
    ./queue/: queue.c queue.h
  group rgb
    ./rgb/: rgb.c rgb.h
  group src
    ./src/: main.c
  group tpm1
    ./tpm1/: tpm1.c tpm1.h
  group uart0
    ./uart0/: uart0.c uart0.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0

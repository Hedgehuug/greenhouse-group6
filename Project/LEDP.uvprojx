# Keil uVision project LEDP.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LEDP
  c flags: Optim=4 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c include: .\rgb;.\pit;.\queue;.\tpm1;.\uart0
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: LEDP.c LEDP.h
  group New Group
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
